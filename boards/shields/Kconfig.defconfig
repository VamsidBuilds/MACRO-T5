## boards/shields/Kconfig.defconfig
```kconfig
if SHIELD_MACROV5

# Name must be less than 16 characters long!
config ZMK_KEYBOARD_NAME
    default "MACROv5"

endif
```
